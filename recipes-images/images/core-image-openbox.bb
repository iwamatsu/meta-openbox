SUMMARY = "A very basic X11 image with openbox"
include openbox-image.inc
